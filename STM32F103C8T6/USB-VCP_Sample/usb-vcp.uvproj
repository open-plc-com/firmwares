# Keil uVision project usb-vcp.uvproj, settings and files
target STM32F103 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: ..\usb_plc
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c include: .\main;.\cmsis;.\spl;.\spl\inc;.\spl\src;.\usb\inc;.\usb\src;.\usb\usb_fs\inc;.\usb\usb_fs\src
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group main
    ./main/: main.c
  group cmsis
    ./cmsis/: system_stm32f10x.c startup_stm32f10x_md.s core_cm3.c
  group usb-fs
    ./usb/src/: hw_config.c usb_pwr.c stm32_it.c usb_prop.c usb_istr.c usb_endp.c usb_desc.c
    ./usb/usb_fs/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group spl
    ./spl/src/: misc.c stm32f10x_dma.c stm32f10x_tim.c stm32f10x_adc.c stm32f10x_usart.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_flash.c stm32f10x_exti.c stm32f10x_spi.c stm32f10x_i2c.c stm32f10x_sdio.c stm32f10x_iwdg.c
