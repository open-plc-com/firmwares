# Keil uVision project w1_gpio.uvproj, settings and files
target 32F103 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: ..\w1_gpio +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER STM32F10X_MD_VL
  c include: .\cmsis;.\cmsis\CoreSupport;.\cmsis\DeviceSupport\ST\STM32F10x;.\spl\inc;.\spl\src;.\main
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group StartUp
    ./main/: startup_stm32f10x_md.s
  group CMSIS
    ./cmsis/: core_cm3.c system_stm32f10x.c
  group SPL
    ./spl/src/: stm32f10x_rcc.c
  group Source Files
    ./main/: main.c
    ./spl/src/: stm32f10x_gpio.c stm32f10x_usart.c misc.c stm32f10x_tim.c stm32f10x_spi.c stm32f10x_iwdg.c stm32f10x_exti.c stm32f10x_adc.c stm32f10x_dac.c stm32f10x_i2c.c stm32f10x_dma.c
